# Keil uVision project STM32VLDiscovery.uvproj, settings and files
target STM32VLDiscovery (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VLDiscovery +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\main;.\STM32F10x_StdPeriph_Driver\inc;.\main\bxCAN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS/CoreSupport/: core_cm3.c
  group main
    ./main/: main.c menu.c template.c menu_func.c stm32f10x_it.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c
  group LCDDriver
    ./main/: 1602driver.c
  group CAN
    ./main/bxCAN/: CAN.c
